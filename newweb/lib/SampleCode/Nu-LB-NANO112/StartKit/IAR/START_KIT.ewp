# IAR project START_KIT.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Nano112AN series Nuvoton Nano112AN series (Nano102AN,Nano112AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Nano1X2Series\Include; ..\..\..\..\Library\StdDriver\Inc; ..\..\..\..\Library\LCDLib\Include; ..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: START_KIT.bin
  ILINK.IlinkOutputFile: START_KIT.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/IAR/: startup_Nano1X2Series.s
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
  group Common
    ../../COMMON/: LCDLIB_Panel.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c lcd.c retarget.c sys.c uart.c
    ../../../../Library/LCDLib/Source/: LCDLIB.c
  group User
    ../: main.c
