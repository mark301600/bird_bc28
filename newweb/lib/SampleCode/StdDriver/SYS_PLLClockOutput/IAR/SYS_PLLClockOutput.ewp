# IAR project SYS_PLLClockOutput.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano112AN series Nuvoton Nano112AN series (Nano102AN,Nano112AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Nano1X2Series\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PLLClockOutput.bin
  ILINK.IlinkOutputFile: SYS_PLLClockOutput.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/IAR/: startup_Nano1X2Series.s
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c wdt.c
  group Source Files
    ../: main.c
