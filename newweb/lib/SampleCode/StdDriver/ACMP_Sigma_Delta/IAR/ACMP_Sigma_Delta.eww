<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ACMP_Sigma_Delta.ewp</path>
  </project>
  <batchBuild/>
</workspace>


