# IAR project Timer_InterTimerTriggerMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano112AN series Nuvoton Nano112AN series (Nano102AN,Nano112AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano1x2Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Timer_InterTimerTriggerMode.bin
  ILINK.IlinkOutputFile: Timer_InterTimerTriggerMode.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/IAR/: startup_Nano1X2Series.s
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
