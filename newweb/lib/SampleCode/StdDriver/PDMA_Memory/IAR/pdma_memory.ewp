# IAR project pdma_memory.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano112AN series Nuvoton Nano112AN series (Nano102AN,Nano112AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\nano1x2Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pdma_memory.bin
  ILINK.IlinkOutputFile: pdma_memory.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/nano1x2Series/Source/IAR/: startup_nano1x2Series.s
    ../../../../Library/Device/Nuvoton/nano1x2Series/Source/: system_nano1x2Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
