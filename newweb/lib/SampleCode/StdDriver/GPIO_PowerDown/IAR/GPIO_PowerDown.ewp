# IAR project GPIO_PowerDown.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano112AN series Nuvoton Nano112AN series (Nano102AN,Nano112AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano1X2Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_PowerDown.bin
  ILINK.IlinkOutputFile: gpio_powerdown.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/IAR/: startup_Nano1X2Series.s
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
