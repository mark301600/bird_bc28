# Keil uVision project 20190107.uvprojx, settings and files
target 20190107 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NANO102ZC2AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.3
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: 20190107
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\hardware;..\lib\Library\CMSIS\Include;..\lib\Library\CMSIS\Driver\Include;..\lib\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../lib/Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../lib/Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group lib
    ./lib/: adc.c clk.c gpio.c i2c.c retarget.c sys.c timer.c uart.c rtc.c
  group user
    ./user/: main.c
  group hardware
    ./hardware/: NuEdu-Basic01_EEPROM.c
